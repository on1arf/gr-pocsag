<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>190</value></param>
<param><key>label</key><value>af_gain</value></param>
<param><key>max</key><value>300</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_deviation</value></param>
<param><key>value</key><value>4500.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pagerfreq</value></param>
<param><key>value</key><value>433.9e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pocsagbitrate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symrate</value></param>
<param><key>value</key><value>38400</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>6</value></param>
<param><key>label</key><value>tx_gain</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>2.0 * math.pi * max_deviation / float(symrate)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>pocsagbitrate</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>samp_rate</key><value>pocsagbitrate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>af_gain*0.7/1000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>af_gain/100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>symrate/pocsagbitrate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

from bitstring import BitArray



class blk(gr.sync_block):
	def CalculateCRCandParity(self,datatype,data):
		cw=data&lt;&lt;11 

		# make leftmost bit "1" for datatype 1 (text)
		if datatype == 1:
			cw |= 0x80000000
		#end if

		local_cw=cw

		for i in range(21):
			if (cw &amp; 0x80000000) &gt; 0:
				cw ^= 0xED200000
			#end if
			cw &lt;&lt;= 1
		#end for

		local_cw |= (cw &gt;&gt; 21)


		parity=0
		cw=local_cw
		for i in range(32):
			if (cw &amp; 0x80000000) &gt; 0:
				parity += 1
			#end if
			cw &lt;&lt;= 1
		#end for

		# make even parity
		local_cw += (parity % 2)

		return(local_cw)
	# end Calculate CRC and Pairy


	def createpocsagmsg(self,address,source,txt):

		# checking input
		if not (0 &lt; address &lt;= 0x1fffff):
			raise ValueError(address)
		#end if

		if not (0 &lt;= source &lt;= 3):
			raise ValueError(source)
		#nd if


		if len(txt) == 0:
			raise ValueError(txt)
		#end if


		if len(txt) &gt;= 40:
			txt=txt[:39]
			print("Warning, text truncated to 39 characters: {txt}".format(txt=txt))
		#end if

		# init pocsag message
		# init data
		# 2 batches
		# 1 batch = sync codeword + 8 frames
		# 1 frame = 1 codeword

		syncpattern = 0xAAAAAAAA
		synccodeword = 0x7cd215d8

		idlepattern  = 0x7a89c197

		# init all codewords with idle pattern: 2 batches = 16 frames = 32 codewords
		codeword = [idlepattern for i in range(32)]


		# part 1: address + source 

		# parse address and source
		addressline=address&gt;&gt;3

		# add address-source
		addressline&lt;&lt;=2
		addressline += source
		# the message starts at the frame address determined by the last 3 bits of the address
		cwnum = ((address % 8) &lt;&lt; 1) # codeword number

		codeword[cwnum]=self.CalculateCRCandParity(datatype = 0, data = addressline)


		# part 2: text
        
		# 2.1 convert text into int, also add EOT char
		ts=[ord(c) for c in txt] + [0x04] 

		# 2.2 make sure all characers are 7 bit
		ts=list(map(lambda x: x%128, ts))

		# 2.3 create one big list of bits
		textbits=''

		for c in ts:
			# BitArray(uint=c,length=7).bin to convert character to 7-character bit-string)
			# note, for transmission, the bit-order must be reversed
			charbits = BitArray(uint=c,length=7)
			# reverse order of bits
			charbits.reverse()

			# add to total string
			textbits += charbits.bin
		#end for

		nbits=len(textbits)

		# 2.4 make the list of bits  a multiple of 20 bits
		textbits += '0' * (20-(nbits % 20))


		# 2.5 for every block of 20 bits, calculate crc and partity, and add to codeword
		ncw = len(textbits)/20 # number of codewords

		startbit=0
		stopbit=20 # (actually, the 19th bit)
		for i in range(ncw):
			thiscw=textbits[startbit:stopbit]
			thiscw_i=int(thiscw,2) # convert list of bits to int

			#move up all pointers
			startbit=stopbit # stopbit is startbit + 20
			stopbit += 20

			#codeword pointer
			cwnum += 1

			# calculate CRC for a text block (datatype = 1)
			codeword[cwnum]=self.CalculateCRCandParity(datatype = 1, data = thiscw_i)
		#end for (number of 


		# done
		# always return the sync-pattern and the first batch
		# sync pattern

		ret = [syncpattern for i in range(18)]
        
		# add sync codeword
		ret.append(synccodeword)

		# add frames 0 to 7 (i.e. codewords 0 to 15)
		ret += [codeword[n] for n in range(16)]


		# if the text has spilled into the 2nd batch, also add that batch
		if cwnum &gt;=  16:
			# add sync codeword
			ret.append(synccodeword)
        
			# and add frames 8 to 15 (i.e. codewords 16 to 31)
			ret += [codeword[n] for n in range(16,32)]

		#end if


		return(ret)

	# end "createpocsagmsg"


	def __init__(self, number = 2060073, source = 0, delay = 1200, text="ON1ARF pocsag Python TEST"):  # only default arguments here
		gr.sync_block.__init__(
			self,
			name='pocsag generator',
			in_sig=[np.int32],
			out_sig=[np.int8]
		)
		self.text = text
		self.count = 0
		self.state = 0
		self.delay = delay
		self.number= int(number)
		self.source = int(source)


		psmsg=self.createpocsagmsg(number,source,text)

		self.pocsagmsg=[]

		for thismsg in psmsg:
			for c in BitArray(uint=thismsg,length=32).bin:
				self.pocsagmsg.append(1 if c == '1' else -1)
		#end for

		self.msglen=len(self.pocsagmsg)
	#end __init__

	#def forecast(self, noutput_items, ninput_items_required):
	#	#setup size of input_items[i] for work call
	#	for i in range(len(ninput_items_required)):
	#		ninput_items_required[i] = noutput_items

	def work(self, input_items, output_items):

		ninput=len(input_items[0])
		#print("NI",ninput)

		#endless loop: break out with "break" if data is ok
		while True:
			if self.state == 0:
				# state 0 -&gt; send pocsag message 
				#print("S0")

				# error checking: "counter" should be less then message size
				if self.count &gt; self.msglen:
					self.count = 0
				#end if

				end=self.count + ninput
				r = self.pocsagmsg[self.count:end]

				if end &gt;= self.msglen:
					#print("S0a")
					# wrap over end of pocsag message: fill up with -1's and go to state 1
					r += [0 for n in range(end-self.msglen)]
					self.state = 1
					self.count = end - self.msglen
					break
				else:
					#print("S0b")
					# pocsag message is not yep completely sent -&gt; just move up pointer
					self.count = end
					break
				#end if

			elif self.state == 1:
				#print("S1")
				# state 1 -&gt; send silence ("-1") during "delay" timeticks
				#print(self.count, self.delay)

				# error checking: "counter" should be less then delay size
				if self.count &gt; self.delay:
					self.count = 0
				#end if

				r= [0 for i in range(ninput)]

				end = self.count + ninput

				if end &lt; self.delay:
					#print("S1a")
					# "delay" periode has not finished yet
					self.count = end
				else:
					#print("S1b")
					# "delay" periode has finished
					self.count = 0
					# go to state 0 (send pocsag message)
					self.state = 0
				#end if

				# done
				break
				
			else:
				self.state == 0
				self.count == 0
				# stay in loop
				continue
			#end if
		#end while

		#print(len(r))

		output_items[0][:]=np.array(r, dtype=np.int8)

		return len(output_items[0])
	#end work
# end class "blk"
</value></param>
<param><key>delay</key><value>pocsagbitrate</value></param>
<param><key>number</key><value>2060073</value></param>
<param><key>source</key><value>0</value></param>
<param><key>text</key><value>'ON1ARF POCSAG'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>+2</value></param>
<param><key>freq0</key><value>pagerfreq</value></param>
<param><key>if_gain0</key><value>tx_gain</value></param>
<param><key>gain0</key><value>1</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>16</value></param>
<param><key>rrate</key><value>float(samp_rate)/float(symrate)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>symrate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
