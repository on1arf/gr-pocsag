<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>190</value></param>
<param><key>label</key><value>af_gain</value></param>
<param><key>max</key><value>300</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_deviation</value></param>
<param><key>value</key><value>4500.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pagerfreq</value></param>
<param><key>value</key><value>433.9e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pocsagbitrate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symrate</value></param>
<param><key>value</key><value>38400</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>3</value></param>
<param><key>label</key><value>tx_gain</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>2.0 * math.pi * max_deviation / float(symrate)</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>af_gain*0.7/1000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>af_gain/100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>symrate/pocsagbitrate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!


"""
#gr-pocsag: a gnuradio embedded python block for sending pocsag messages
#-----------------------------------------------------------------------
#
#
#This is the alpha test release of gr-pocsag, a embedded python block for generating and
#sending pocsag message.
#
#The gnu-radio companion example uses a hackRF to send a pocsag-message on 433.900 Mhz.
#
#
#The block generates the bitpattern for a POCSAG-message, broadcasts it once and then going into a loop
#to shut down the transmitter module of the HackRF.
#
#
#The python code itself is located inside the "pocsag generator" epy_block and as a seperate file "gr-pocsagsend.py".
#
#
# (C) Kristoff Bonne, ON1ARF
# GPL v3
#
#Release-information:
#Version: 0.0.1 (20180826)
#Version: 0.0.2 (20180828)
#Version: 0.0.3 (20181006): correction idle pattern and changing "20 bits padding" pattern
#
# 73s . kristoff - ON1ARF


import numpy as np
from gnuradio import gr

from bitstring import BitArray

import time



class pocsagsender(gr.sync_block):
	def __CalculateCRCandParity(self,datatype,data):
		cw=data&lt;&lt;11 

		# make leftmost bit "1" for datatype 1 (text)
		if datatype == 1:
			cw |= 0x80000000
		#end if

		local_cw=cw

		for i in range(21):
			if (cw &amp; 0x80000000) &gt; 0:
				cw ^= 0xED200000
			#end if
			cw &lt;&lt;= 1
		#end for

		local_cw |= (cw &gt;&gt; 21)


		parity=0
		cw=local_cw
		for i in range(32):
			if (cw &amp; 0x80000000) &gt; 0:
				parity += 1
			#end if
			cw &lt;&lt;= 1
		#end for

		# make even parity
		local_cw += (parity % 2)

		return(local_cw)
	# end Calculate CRC and Pairy


	def __createpocsagmsg(self,address,source,txt):

		# checking input
		if not (0 &lt; address &lt;= 0x1fffff):
			raise ValueError(address)
		#end if

		if not (0 &lt;= source &lt;= 3):
			raise ValueError(source)
		#nd if


		if len(txt) == 0:
			raise ValueError(txt)
		#end if


		if len(txt) &gt;= 40:
			txt=txt[:39]
			print("Warning, text truncated to 39 characters: {txt}".format(txt=txt))
		#end if

		# init pocsag message
		# init data
		# 2 batches
		# 1 batch = sync codeword + 8 frames
		# 1 frame = 1 codeword

		syncpattern = 0xAAAAAAAA
		synccodeword = 0x7cd215d8

		idlepattern  = 0x7ac9c197

		# init all codewords with idle pattern: 2 batches = 16 frames = 32 codewords
		codeword = [idlepattern for i in range(32)]


		# part 1: address + source 

		# parse address and source
		addressline=address&gt;&gt;3

		# add address-source
		addressline&lt;&lt;=2
		addressline += source
		# the message starts at the frame address determined by the last 3 bits of the address
		cwnum = ((address % 8) &lt;&lt; 1) # codeword number

		codeword[cwnum]=self.__CalculateCRCandParity(datatype = 0, data = addressline)


		# part 2: text
        
		# 2.1 convert text into int, also add EOT char
		ts=[ord(c) for c in txt] + [0x04] 

		# 2.2 make sure all characers are 7 bit
		ts=list(map(lambda x: x%128, ts))

		# 2.3 create one big list of bits
		textbits=''

		for c in ts:
			# BitArray(uint=c,length=7).bin to convert character to 7-character bit-string)
			# note, for transmission, the bit-order must be reversed
			charbits = BitArray(uint=c,length=7)
			# reverse order of bits
			charbits.reverse()

			# add to total string
			textbits += charbits.bin
		#end for

		nbits=len(textbits)

		# 2.4 make the list of bits  a multiple of 20 bits
		bitstoadd=20-(nbits % 20)

		if bitstoadd == 20:
			bitstoadd = 0
		#end if
		bitstoadd_rest = bitstoadd%2
		bitstoadd_2bit = bitstoadd &gt;&gt; 1
		textbits += '01' * bitstoadd_2bit
		if bitstoadd_rest == 1:
			textbits += '0'
		#end if


		# 2.5 for every block of 20 bits, calculate crc and partity, and add to codeword
		ncw = len(textbits)/20 # number of codewords

		startbit=0
		stopbit=20 # (actually, the 19th bit)
		for i in range(ncw):
			thiscw=textbits[startbit:stopbit]
			thiscw_i=int(thiscw,2) # convert list of bits to int

			#move up all pointers
			startbit=stopbit # stopbit is startbit + 20
			stopbit += 20

			#codeword pointer
			cwnum += 1

			# calculate CRC for a text block (datatype = 1)
			codeword[cwnum]=self.__CalculateCRCandParity(datatype = 1, data = thiscw_i)
		#end for (number of 


		# done

		# now create complete pocsag message
		# sync pattern
		ret = [syncpattern for i in range(18)]
        
		# add sync codeword of 1st batch
		ret.append(synccodeword)

		# add frames 0 to 7 (i.e. codewords 0 to 15)
		ret += [codeword[n] for n in range(16)]


		
		# create add 2nd batch if the text has spilled into the 2nd batch
		if cwnum &gt;=  16:
			# long message, 2 batches
			nbatch=2

			# add sync codeword
			ret.append(synccodeword)
        
			# and add frames 8 to 15 (i.e. codewords 16 to 31)
			ret += [codeword[n] for n in range(16,32)]
		else:
			# short message, 1 batch
			nbatch=1

		#end else - ifif


		return((nbatch,ret))

	# end "createpocsagmsg"


	def __init__(self, number = 2060073, source = 0,  sleeptime= 5, text="ON1ARF pocsag Python gnuradio"):  # only default arguments here
		gr.sync_block.__init__(
			self,
			name='pocsag generator',
			in_sig=[],
			out_sig=[np.int8]
		)


		self.set_output_multiple(640)
			# pocsag messages are either 1 batch (35 codeword = 120 octets), or 2 batches (52 codewords = 208 octets)
			# make the stream a little bit longer to fit a multiple of 20 codewords
			# pocsag message of 1 batch -&gt; add 5 cw -&gt; 40 (= 20 * 2) codewords
			# pocsag message of 2 batches -&gt; add 8 cw -&gt; 60 (=20 *3) codewords
			# 20 cw = 80 octets = 640 bits

		self.state = 0
		self.sleeptime = sleeptime
		self.number= int(number)
		self.source = int(source)


		nbatch,psmsg=self.__createpocsagmsg(number,source,text)

		# for a short message (nbtach=1), add 5 octest = 40 bits
		# for a long message (nbatch=2), add 8 octets = 64 bits

		if nbatch == 1:
			self.pocsagmsg=[0 for i in range(20)]
		elif nbatch == 2:
			self.pocsagmsg=[0 for i in range(32)]
		else:
			raise ValueError(nbatch)
		#end if
			

		for thismsg in psmsg:
			for c in BitArray(uint=thismsg,length=32).bin:
				self.pocsagmsg.append(1 if c == '1' else -1)
		#end for

		# now add tail (all 0)
		if nbatch == 1:
			self.pocsagmsg+=[0 for i in range(20)]
		elif nbatch == 2:
			self.pocsagmsg+=[0 for i in range(32)]
		else:
			raise ValueError(nbatch)
		#end if

		self.msglen=len(self.pocsagmsg)

	#end __init__

	#def forecast(self, noutput_items, ninput_items_required):
	#	#setup size of input_items[i] for work call
	#	for i in range(len(ninput_items_required)):
	#		ninput_items_required[i] = noutput_items

	def work(self, input_items, output_items):

		if self.state == 0:
			# state 0 -&gt; send pocsag message 

			output_items[0][:self.msglen]=np.array(self.pocsagmsg, dtype=np.int8)

			self.state = 1 # after this, go to sleep 
			return self.msglen
		#end if

		# state 1: sleep
		time.sleep(self.sleeptime)

		# then go back to state 0 (transmit)
		self.state = 0

		return -1 # return without any data
	#end work
# end class "pocsagsender"
</value></param>
<param><key>number</key><value>2060073</value></param>
<param><key>sleeptime</key><value>5</value></param>
<param><key>source</key><value>0</value></param>
<param><key>text</key><value>'ON1ARF pocsag Python gnuradio'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>+2</value></param>
<param><key>freq0</key><value>pagerfreq</value></param>
<param><key>if_gain0</key><value>tx_gain</value></param>
<param><key>gain0</key><value>1</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>16</value></param>
<param><key>rrate</key><value>float(samp_rate)/float(symrate)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>symrate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
